# Keil uVision project LCD_PressureGage.uvprojx, settings and files
target LCD_PressureGage (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LCD_PressureGage +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F072xB
  c misc: --no-multibyte-chars
  c include: ..\Application;..\Bsp;..\CMSIS;..\PY32F072_HAL_Driver\Include;..\PY32F072_HAL_Driver\Drivers\Inc;..\Startup
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../Application/: main.c LCD.c App_Key.c App_System.c App_ParamInput.c App_ExternalOutput.c MeterInterface.c py32f072_hal_msp.c py32f072_it.c APP_JM1203.c APP_ModReg.c APP_Sensor.c ModbusRTU.c
  group Bsp
    ../Bsp/: GPIO_Config.c Uart_Config.c ADC_Config.c PWM_Config.c SPI_Config.c Flash_Config.c Timer_Config.c
  group CMSIS
    ../CMSIS/: system_py32f072.c
  group Startup
    ../Startup/: startup_py32f072xx.s
  group PY32F072_HAL_Driver
    ../PY32F072_HAL_Driver/Drivers/Src/: py32f072_hal.c py32f072_hal_adc.c py32f072_hal_adc_ex.c py32f072_hal_comp.c py32f072_hal_cortex.c py32f072_hal_crc.c py32f072_hal_ctc.c py32f072_hal_div.c py32f072_hal_dma.c py32f072_hal_exti.c py32f072_hal_flash.c py32f072_hal_gpio.c py32f072_hal_i2c.c py32f072_hal_irda.c py32f072_hal_iwdg.c py32f072_hal_lcd.c py32f072_hal_lptim.c py32f072_hal_opa.c py32f072_hal_opa_ex.c py32f072_hal_pwr.c py32f072_hal_rcc.c py32f072_hal_rcc_ex.c py32f072_hal_smartcard.c py32f072_hal_spi.c py32f072_hal_tim.c py32f072_hal_tim_ex.c py32f072_hal_uart.c py32f072_hal_usart.c py32f072_hal_wwdg.c
software components: CMSIS:CORE 5.4.0
